options:
  parameters:
    author: Elian
    category: '[Modulos_L1A3]'
    copyright: uis-e2t-ciee
    description: modulador en cuadratura
    generate_options: hb
    id: Modulador_QAM
    output_language: python
    title: Modulador QAM
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: Ampliud portadora
    type: eng_float
    value: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: m1
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: m2
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_float_to_complex_0, '0']
- [pad_source_1, '0', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
