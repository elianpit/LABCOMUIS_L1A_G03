options:
  parameters:
    author: elian
    copyright: uis
    description: transmisor de carrier suprimida
    generate_options: qt_gui
    id: Transmisor_DSB_SC
    output_language: python
    title: Transmisor_DSB_SC
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud modulante
    start: '0'
    step: '100E-6'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '100E-6'
    stop: '1'
    value: '100E-3'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del Tx
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: 50E6
    step: 1E6
    stop: 2.2E9
    value: 50E6
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente Ka
    start: '-2'
    step: '100E-6'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: Envolvente_compleja_DSB_SC_0
  id: Envolvente_compleja_DSB_SC
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: Lab3_comu1_part1_0
  id: Lab3_comu1_part1
  parameters:
    I_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    comment: esto es m(t)
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: GTX
    len_tag_name: ''
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_compleja_DSB_SC_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_compleja_DSB_SC_0, '0']
- [analog_sig_source_x_0, '0', Lab3_comu1_part1_0, '0']

metadata:
  file_format: 1
