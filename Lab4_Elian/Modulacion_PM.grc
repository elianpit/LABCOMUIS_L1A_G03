options:
  parameters:
    author: Elian
    copyright: uis
    description: modulacion en fase
    generate_options: qt_gui
    id: Modulacion_PM
    output_language: python
    title: Modulacion PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Ampliud Carrier
    start: '0'
    step: '1e-6'
    stop: '5'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '1e-6'
    stop: '5'
    value: '1'
  states: {}
- name: FC
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia GTX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: ceficiente kp
    start: '0'
    step: '1E-6'
    stop: '50'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: 1e3
    step: '100'
    stop: 20e3
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 125e5
  states: {}
- name: Envolvente_compleja_PM_0
  id: Envolvente_compleja_PM
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: Lab3_comu1_part1_0
  id: Lab3_comu1_part1
  parameters:
    I_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: FC
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_compleja_PM_0, '0', blocks_complex_to_mag_0, '0']
- [Envolvente_compleja_PM_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_compleja_PM_0, '0', qtgui_time_sink_x_0, '0']
- [Envolvente_compleja_PM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_compleja_PM_0, '0']
- [blocks_complex_to_mag_0, '0', Lab3_comu1_part1_0, '0']

metadata:
  file_format: 1
