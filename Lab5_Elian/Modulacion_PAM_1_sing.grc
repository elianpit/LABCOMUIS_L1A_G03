options:
  parameters:
    author: elian ciee
    copyright: ciee e3t
    description: Modulacion PAM para una señal
    generate_options: qt_gui
    id: Modulacion_PAM_1
    output_language: python
    title: Modulacion_PAM_1.0
  states: {}

blocks:
- name: fm
  id: variable
  parameters:
    value: fs/10
  states: {}
- name: fs
  id: variable
  parameters:
    value: samp_rate/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: ancho de pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: Modulacion_PAM_0
  id: Modulacion_PAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Modulacion_PAM_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', Modulacion_PAM_0, '0']

metadata:
  file_format: 1
